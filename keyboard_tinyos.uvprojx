# Keil uVision project keyboard_tinyos.uvprojx, settings and files
target keyboard_tinyos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keyboard_tinyos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\OS;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./: readme.txt
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_dma.c
  group SYS
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/: keyboard.c timer.c rtc.c tsensor.c adc.c ds18b20.c gps.c uart4.c
  group OS
    ./OS/: tinyOS.c
